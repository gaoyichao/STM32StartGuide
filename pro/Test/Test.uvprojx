# Keil uVision project Test.uvprojx, settings and files
target Test (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Particle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\inc;..\..\lib\stm32\inc;..\..\lib\cmsis\inc;..\..\board\inc;..\..\lib\utils\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Test.sct
  group app
    ./app/: main.c interrupts.c
  group libstm32
    ../../lib/stm32/src/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_timer.c stm32f4xx_sdio.c stm32f4xx_flash.c
  group board
    ../../board/src/: led.c usart1.c W25Q128.c i2c1.c sccb.c ov2640.c dcmi.c sdio.c board_asm.s
  group libutils
    ../../lib/utils/src/: utils.c queue.int.c
